Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-07-20T15:12:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 15:12:31 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{8C3E0A8E-2C5B-4A72-B69B-33254D9DB4F1}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 15:12:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 15:12:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 15:12:31 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Charm viseci ormaric_R18, Charm viseci ormaric_R18:Charm viseci ormaric_R18:438611
In: Level 1
Type - ElementType: Charm viseci ormaric_R18; Material: AQ_Bijela sjajna
Type - Identity Data - Boja: bijela sjajna, bijela bodega, grafitno crna, onix siva, siva pearl; Izradio: Intelika d.o.o.; Manufacturer: Aquaestil; Materijal: MDF; Model: CHARM VISEĆI ORMARIĆ; Mogućnost ugradnje: zid; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Type Name: Charm viseci ormaric_R18; Web adresa: https://www.aquaestil.hr/hr/proizvodi/kupaonski-namjestaj/20-.html
Type - Materials and Finishes - Materijal ormar: AQ_Bijela sjajna
Type - Other - Category: Furniture; Family Name: Charm viseci ormaric_R18
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.12701 m2; Visina ugradnje od poda: 1000 mm; Volume: 0.0154773 m3
Other - Family: Charm viseci ormaric_R18: Charm viseci ormaric_R18; Family and Type: Charm viseci ormaric_R18: Charm viseci ormaric_R18; Type: Charm viseci ormaric_R18: Charm viseci ormaric_R18; Type Id: Charm viseci ormaric_R18: Charm viseci ormaric_R18
Phasing - Phase Created: New Construction
